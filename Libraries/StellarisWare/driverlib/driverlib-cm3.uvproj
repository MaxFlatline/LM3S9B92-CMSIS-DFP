# Keil uVision project driverlib-cm3.uvproj, settings and files
target driverlib-cm3 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LM3S101 Texas Instruments
  cpu: IRAM(0x20000000-0x200007FF) IROM(0-0x1FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: driverlib-cm3 (library)
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: rvmdk
  c include: ..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x800
  group Source
    ./: adc.c can.c comp.c cpu.c epi.c ethernet.c flash.c gpio.c hibernate.c i2c.c i2s.c interrupt.c mpu.c pwm.c qei.c ssi.c sysctl.c systick.c timer.c uart.c udma.c usb.c watchdog.c
  group Documentation
    ./: readme.txt
