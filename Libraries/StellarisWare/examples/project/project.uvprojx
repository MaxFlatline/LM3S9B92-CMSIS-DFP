# Keil uVision project project.uvprojx, settings and files
target project (6210000::V6.21::ARMCLANG)
  device: LM3S9D96 Texas Instruments
  pack: Keil.LM3S_DFP.1.1.1
  cpu: IRAM(0x20000000,0x00018000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  AfterMake: fromelf --bin --output .\rvmdk\project.bin .\rvmdk\project.axf
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: rvmdk PART_LM3S9D96, DEBUG
  c include: ..\..
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: project.sct
  link misc: --entry Reset_Handler
  group Source
    ./: project.c startup_rvmdk.S
  group Libraries
    ../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
  group Documentation
    ./: readme.txt
software components: CMSIS:CORE 5.6.0
