# Keil uVision project Evalbot_Helloworld.uvprojx, settings and files
target Evalbot_Release (6240000::V6.24::ARMCLANG)
  device: LM3S9B92 Texas Instruments
  pack: Keil.LM3S_DFP.1.1.1
  cpu: IRAM(0x20000000,0x00018000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Evalbot_Helloworld
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\Sources\Core\inc;..\..\..\Libraries\StellarisWare;..\..\..\Libraries\StellarisWare\driverlib;..\..\..\Sources\CMSIS_Drivers\GPIO;..\..\..\Sources\CMSIS_Drivers\UART;..\..\..\Sources\Device\Include\LM3S9B92;..\..\..\Sources\CMSIS_Drivers\I2C;..\..\..\Sources\CMSIS_Drivers\Common\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x13000
  memory RVCT10: RAM 0x20013000 size 0x5000
  group Core
    ../../../Sources/Core/src/: main.c
    ../../../Sources/Device/Source/LM3S9B92/: system_lm3s9b92.c
    ../../../Sources/Device/Source/LM3S9B92/ARM/AC5/: startup_lm3s9b92_ac5_noSct.s
  group StellarisWare
    ../../../Libraries/StellarisWare/driverlib/: rom.h rom_map.h
  group HAL
    ../../../Libraries/StellarisWare/driverlib/: adc.c can.c comp.c cpu.c epi.c ethernet.c flash.c gpio.c hibernate.c i2c.c i2s.c interrupt.c mpu.c pwm.c qei.c ssi.c sysctl.c systick.c timer.c uart.c udma.c usb.c watchdog.c
  group BSP\EVALBOT
    ../../../Sources/BSP/Evalbot/Common/: bsp_evalbot.c
  group CMSIS-Core\Common
    ../../../Sources/Device/Include/LM3S9B92/: SYS_LM3S9B92_Config.h
  group CMSIS-Driver\GPIO
    ../../../Sources/CMSIS_Drivers/GPIO/: GPIO_LM3S9B92.c
  group CMSIS-Driver\USART
    ../../../Sources/CMSIS_Drivers/UART/: UART_LM3S9B92.c
  group CMSIS-Driver\SPI
    ../../../Sources/CMSIS_Drivers/SPI/: SPI_LM3S9B92.c
  group CMSIS-Driver\I2C
    ../../../Sources/CMSIS_Drivers/I2C/: I2C_LM3S9B92.c I2C_LM3S9B92_Config.h
  group CMSIS-Driver\Common
    ../../../Sources/CMSIS_Drivers/Common/Include/: driver_utils.h
target Evalbot_Debug (6240000::V6.24::ARMCLANG)
  device: LM3S9B92 Texas Instruments
  pack: Keil.LM3S_DFP.1.1.1
  cpu: as above
  output: Evalbot_Helloworld
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: TARGET_IS_TEMPEST_RC3, PART_LM3S9B92
  c misc: -gdwarf-2
  c include: ..\..\..\Libraries\StellarisWare;..\..\..\Libraries\StellarisWare\driverlib;..\..\..\Sources\CMSIS_Drivers\GPIO;..\..\..\Sources\CMSIS_Drivers\UART;..\..\..\Sources\CMSIS_Drivers\Common;..\..\..\Sources\Device\Include\LM3S9B92;..\..\..\Sources\Core\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x13000
  memory RVCT10: RAM 0x20013000 size 0x5000
target Evalbot_Debug_RAM (6210000::V6.21::ARMCLANG)
  device: LM3S9B92 Texas Instruments
  pack: Keil.LM3S_DFP.1.1.1
  cpu: as above
  output: Evalbot_Helloworld
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
software components: CMSIS Driver Validation:Framework 2.0.0, CMSIS Driver Validation:I2C 1.4.0, CMSIS Driver:GPIO:Custom 1.0.0, CMSIS Driver:I2C:Custom 1.0.0, CMSIS Driver:SPI:Custom 1.0.0, CMSIS Driver:USART:Custom 1.0.0, CMSIS-Compiler:CORE 1.2.1, CMSIS-Compiler:OS Interface:CMSIS-RTOS2 2.1.0, CMSIS-Compiler:STDOUT:Event Recorder 1.1.0, CMSIS-View:Event Recorder 1.6.0, CMSIS:CORE 6.2.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.9.1, Test:Unity 2.5.0
